# Keil uVision project stopwatch-v2.uvprojx, settings and files
target stopwatch-v2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743VIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stopwatch-v2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./hardware/LCD;./hardware/TOUCH;./hardware/LVGL;./hardware/LVGL/src;./hardware/LVGL/examples/porting;./hardware/LVGL/demos/widgets/assets;./hardware/LVGL/demos/widgets;./hardware/LVGL/demos/benchmark;./hardware/LVGL/demos/benchmark/assets;./hardware/gps;./hardware/gui/src/generated;./hardware/gui/src/custom;./hardware/DPS310;./hardware/IST8301;./hardware/mpu6050;./hardware/bikeSys;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;./hardware/SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c fmc.c i2c.c memorymap.c sdmmc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Hardware
    ./hardware/LCD/: font.h TFTLCD.c TFTLCD.h
    ./hardware/TOUCH/: ctiic.c ctiic.h ctp.c ctp.h
    ./hardware/gps/: gps.c gps.h
    ./hardware/DPS310/: dps310.c dps310.h
    ./hardware/IST8301/: IST8301.c IST8301.h
    ./hardware/mpu6050/: dmpKey.h dmpmap.h IIC.c IIC.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h
    ./hardware/bikeSys/: bikeSys.c bikeSys.h
    ./hardware/SD/: file_operate.c file_operate.h
  group LVGL_myGUI
    ./hardware/gui/src/custom/: custom.c
    ./hardware/gui/src/generated/guider_fonts/: lv_font_montserratMedium_16.c lv_font_montserratMedium_45.c lv_font_montserratMedium_12.c
    ./hardware/gui/src/generated/images/: _12_117x36.c _16_alpha_96x121.c _qsLogo_243x72.c _yh_alpha_26x13.c _yh_alpha_26x17.c _yl_alpha_26x13.c _yl_alpha_26x17.c _yl_alpha_55x22.c _stopwatch_243x72.c
    ./hardware/gui/src/generated/: events_init.c gui_guider.c setup_scr_menu.c setup_scr_open.c setup_scr_show.c widgets_init.c
  group LVGL_conf
    ./hardware/LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ./hardware/LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group LVGL_scr
    ./hardware/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./hardware/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ./hardware/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./hardware/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./hardware/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./hardware/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./hardware/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./hardware/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./hardware/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./hardware/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./hardware/LVGL/src/extra/layouts/flex/: lv_flex.c
    ./hardware/LVGL/src/extra/layouts/grid/: lv_grid.c
    ./hardware/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ./hardware/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./hardware/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ./hardware/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./hardware/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./hardware/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ./hardware/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./hardware/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ./hardware/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./hardware/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./hardware/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./hardware/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ./hardware/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ./hardware/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ./hardware/LVGL/src/extra/others/monkey/: lv_monkey.c
    ./hardware/LVGL/src/extra/others/msg/: lv_msg.c
    ./hardware/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ./hardware/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ./hardware/LVGL/src/extra/themes/default/: lv_theme_default.c
    ./hardware/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ./hardware/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ./hardware/LVGL/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    ./hardware/LVGL/src/extra/widgets/chart/: lv_chart.c
    ./hardware/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./hardware/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./hardware/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ./hardware/LVGL/src/extra/widgets/led/: lv_led.c
    ./hardware/LVGL/src/extra/widgets/list/: lv_list.c
    ./hardware/LVGL/src/extra/widgets/menu/: lv_menu.c
    ./hardware/LVGL/src/extra/widgets/meter/: lv_meter.c
    ./hardware/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ./hardware/LVGL/src/extra/widgets/span/: lv_span.c
    ./hardware/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ./hardware/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ./hardware/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ./hardware/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ./hardware/LVGL/src/extra/widgets/win/: lv_win.c
    ./hardware/LVGL/src/extra/: lv_extra.c
    ./hardware/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./hardware/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./hardware/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./hardware/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_demo
    ./hardware/LVGL/demos/widgets/: lv_demo_widgets.c lv_demo_widgets.h
    ./hardware/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ./hardware/LVGL/demos/benchmark/: lv_demo_benchmark.c lv_demo_benchmark.h
    ./hardware/LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 5.2.0
